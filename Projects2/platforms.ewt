<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>FRDM_K64</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>FRDM_K64_SPP</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>Applications</name>
    <group>
      <name>Bootloader</name>
      <file>
        <name>$PROJ_DIR$\..\Bootloader\BootloaderEntrance.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Bootloader\Getline.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Bootloader\menu.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Bootloader\Update_for_OTA.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Bootloader\ymodem.c</name>
      </file>
    </group>
    <group>
      <name>COM.MXCHIP.HA</name>
      <file>
        <name>$PROJ_DIR$\..\Demos\COM.MXCHIP.HA\HaProtocol.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Demos\COM.MXCHIP.HA\LocalTcpServer.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Demos\COM.MXCHIP.HA\MICOAppEntrance.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Demos\COM.MXCHIP.HA\MICOBonjour.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Demos\COM.MXCHIP.HA\MICOConfigDelegate.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Demos\COM.MXCHIP.HA\RemoteTcpClient.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Demos\COM.MXCHIP.HA\stm32f2xx_it.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Demos\COM.MXCHIP.HA\UartRecv.c</name>
      </file>
    </group>
    <group>
      <name>COM.MXCHIP.HOMEKIT</name>
      <file>
        <name>$PROJ_DIR$\..\Demos\COM.Apple.HomeKit\HomeKitPairlist.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Demos\COM.Apple.HomeKit\HomekitProfiles.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Demos\COM.Apple.HomeKit\HomeKitSecurity_Debug.a</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Demos\COM.Apple.HomeKit\HomeKitSecurity_Release.a</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Demos\COM.Apple.HomeKit\HomeKitServer.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Demos\COM.Apple.HomeKit\HomeKitUserInterface.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Demos\COM.Apple.HomeKit\MICOAppEntrance.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Demos\COM.Apple.HomeKit\MICOBonjour.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Demos\COM.Apple.HomeKit\MICOConfigDelegate.c</name>
      </file>
    </group>
    <group>
      <name>COM.MXCHIP.SPP</name>
      <file>
        <name>$PROJ_DIR$\..\Demos\COM.MXCHIP.SPP\LocalTcpServer.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Demos\COM.MXCHIP.SPP\MICOAppEntrance.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Demos\COM.MXCHIP.SPP\MICOBonjour.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Demos\COM.MXCHIP.SPP\MICOConfigDelegate.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Demos\COM.MXCHIP.SPP\RemoteTcpClient.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Demos\COM.MXCHIP.SPP\SppProtocol.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Demos\COM.MXCHIP.SPP\UartRecv.c</name>
      </file>
    </group>
    <group>
      <name>WeiChat.SPP</name>
      <file>
        <name>$PROJ_DIR$\..\Demos\COM.WECHAT.SPP\LocalTcpServer.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Demos\COM.WECHAT.SPP\MICOAppEntrance.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Demos\COM.WECHAT.SPP\MICOBonjour.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Demos\COM.WECHAT.SPP\MICOConfigDelegate.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Demos\COM.WECHAT.SPP\RemoteTcpClient.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Demos\COM.WECHAT.SPP\SppProtocol.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Demos\COM.WECHAT.SPP\UartRecv.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>External</name>
    <group>
      <name>Curve25519</name>
      <file>
        <name>$PROJ_DIR$\..\External\Curve25519\curve25519-donna.c</name>
        <configuration>
          <name>FRDM_K64</name>
        </configuration>
        <configuration>
          <name>FRDM_K64_SPP</name>
        </configuration>
      </file>
    </group>
    <group>
      <name>GladmanAES</name>
    </group>
    <group>
      <name>JSON-C</name>
      <file>
        <name>$PROJ_DIR$\..\External\JSON-C\arraylist.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\External\JSON-C\debug.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\External\JSON-C\json_object.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\External\JSON-C\json_tokener.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\External\JSON-C\json_util.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\External\JSON-C\linkhash.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\External\JSON-C\printbuf.c</name>
      </file>
    </group>
    <group>
      <name>SHAUtils</name>
      <file>
        <name>$PROJ_DIR$\..\External\SHAUtils\hkdf.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\External\SHAUtils\hmac.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\External\SHAUtils\sha1.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\External\SHAUtils\sha224-256.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\External\SHAUtils\sha384-512.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\External\SHAUtils\usha.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>include</name>
    <group>
      <name>MicoDrivers</name>
      <file>
        <name>$PROJ_DIR$\..\include\MicoDrivers\MicoDriverAdc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\include\MicoDrivers\MicoDriverFlash.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\include\MicoDrivers\MicoDriverGpio.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\include\MicoDrivers\MicoDriverI2c.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\include\MicoDrivers\MicoDriverMFiAuth.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\include\MicoDrivers\MicoDriverPwm.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\include\MicoDrivers\MicoDriverRng.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\include\MicoDrivers\MicoDriverRtc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\include\MicoDrivers\MicoDriverSpi.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\include\MicoDrivers\MicoDriverUart.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\include\MicoDrivers\MicoDriverWdg.h</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\..\include\MICO.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\include\MicoAES.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\include\MicoAlgorithm.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\include\MicoPlatform.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\include\MICORTOS.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\include\MicoSocket.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\include\MicoSRPServer.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\include\MicoWlan.h</name>
    </file>
  </group>
  <group>
    <name>Library</name>
    <file>
      <name>$PROJ_DIR$\..\Library\MICOConfig.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Library\MicoCrypto.a</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Library\MicoSrpServer.a</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Library\mxchipWNet_cm3_sdio.a</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Library\mxchipWNet_cm3_spi.a</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Library\mxchipWNet_cm4f_sdio.a</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Library\mxchipWNet_cm4f_spi.a</name>
    </file>
  </group>
  <group>
    <name>MICO</name>
    <group>
      <name>Easylink</name>
      <file>
        <name>$PROJ_DIR$\..\MICO\EasyLink\EasyLink.c</name>
      </file>
    </group>
    <group>
      <name>WAC</name>
      <file>
        <name>$PROJ_DIR$\..\MICO\WAC\MFi_WAC_CM3_Debug.a</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\MICO\WAC\MFi_WAC_CM3_Release.a</name>
      </file>
    </group>
    <group>
      <name>WPS</name>
      <file>
        <name>$PROJ_DIR$\..\MICO\WPS\WPS.c</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\..\MICO\MICOConfigMenu.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\MICO\MICOConfigServer.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\MICO\MICOEntrance.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\MICO\MICONotificationCenter.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\MICO\MICONTPClient.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\MICO\MICOParaStorage.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\MICO\MICOSystemMonitor.c</name>
    </file>
  </group>
  <group>
    <name>Platforms</name>
    <group>
      <name>boards</name>
      <group>
        <name>FRDM_K64</name>
        <file>
          <name>$PROJ_DIR$\..\Platform\FRDM_K64\utilities\fsl_debug_console.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Platform\FRDM_K64\irq_handler\fsl_dspi_irq.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Platform\FRDM_K64\hal\fsl_edma_common.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Platform\FRDM_K64\hal\fsl_edma_driver.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Platform\FRDM_K64\irq_handler\fsl_edma_irq.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Platform\FRDM_K64\hal\fsl_uart_edma_driver.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Platform\FRDM_K64\hal\fsl_uart_hal.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Platform\FRDM_K64\boards\gpio_pins.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Platform\FRDM_K64\boards\hardware_init.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Platform\FRDM_K64\utilities\mem_tools.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Platform\FRDM_K64\boards\pin_mux.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Platform\FRDM_K64\platform.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Platform\FRDM_K64\startup\startup.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Platform\FRDM_K64\startup\startup_MK64F12.s</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Platform\FRDM_K64\startup\system_MK64F12.c</name>
        </file>
        <configuration>
          <name>FRDM_K64</name>
        </configuration>
        <configuration>
          <name>FRDM_K64_SPP</name>
        </configuration>
      </group>
    </group>
    <group>
      <name>common</name>
      <group>
        <name>Cortex-m3</name>
      </group>
      <group>
        <name>Cortex-m4</name>
        <file>
          <name>$PROJ_DIR$\..\Platform\Common\Cortex-M4\crt0_IAR.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Platform\Common\Cortex-M4\hardfault.c</name>
        </file>
      </group>
      <group>
        <name>Driver</name>
        <group>
          <name>spi_flash</name>
          <file>
            <name>$PROJ_DIR$\..\Platform\Common\Drivers\spi_flash\spi_flash.c</name>
          </file>
        </group>
        <file>
          <name>$PROJ_DIR$\..\Platform\Common\Drivers\MicoDriverMFiAuth.a</name>
        </file>
      </group>
      <group>
        <name>IAR</name>
        <file>
          <name>$PROJ_DIR$\..\Platform\Common\IAR\stdio_IAR.c</name>
        </file>
      </group>
    </group>
    <group>
      <name>vendor</name>
      <group>
        <name>FSL_MK64Fxx12</name>
        <file>
          <name>$PROJ_DIR$\..\Platform\FRDM_K64\hal\edma.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Platform\Common\Cortex-M4\Freescale\flash_kinetis.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Platform\Common\Cortex-M4\Freescale\flash_kinetisRamFunc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Platform\Common\Cortex-M4\Freescale\fsl_rtc_irq.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Platform\Common\Cortex-M4\Freescale\gpio_irq.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Platform\Common\Cortex-M4\Freescale\k64_gpio.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Platform\Common\Cortex-M4\Freescale\k64_spi.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Platform\Common\Cortex-M4\Freescale\ksdk_freertos_lib.a</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Platform\Common\Cortex-M4\Freescale\ksdk_platform.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Platform\Common\Cortex-M4\Freescale\MicoDriverAdc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Platform\Common\Cortex-M4\Freescale\MicoDriverFlash.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Platform\Common\Cortex-M4\Freescale\MicoDriverGpio.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Platform\Common\Cortex-M4\Freescale\MicoDriverI2c.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Platform\Common\Cortex-M4\Freescale\MicoDriverPwm.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Platform\Common\Cortex-M4\Freescale\MicoDriverRng.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Platform\Common\Cortex-M4\Freescale\MicoDriverRtc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Platform\Common\Cortex-M4\Freescale\MicoDriverSpi.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Platform\Common\Cortex-M4\Freescale\MicoDriverUart.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Platform\Common\Cortex-M4\Freescale\MicoDriverWdg.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Platform\Common\Cortex-M4\Freescale\EMW1062_Driver\read_wifi_firmware.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Platform\Common\Cortex-M4\Freescale\EMW1062_Driver\wlan_platform.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Platform\Common\Cortex-M4\Freescale\EMW1062_Driver\SPI\wwd_bus.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Platform\Common\Cortex-M4\Freescale\wwd_bus.c</name>
        </file>
        <configuration>
          <name>FRDM_K64</name>
        </configuration>
        <configuration>
          <name>FRDM_K64_SPP</name>
        </configuration>
      </group>
    </group>
  </group>
  <group>
    <name>support</name>
    <file>
      <name>$PROJ_DIR$\..\Library\support\AESUtils.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Library\support\HTTPUtils.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Library\support\MDNSUtils.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Library\support\RingBufferUtils.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Library\support\SecurityUtils.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Library\support\SHAUtils.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Library\support\SocketUtils.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Library\support\StringUtils.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Library\support\TimeUtils.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Library\support\TLVUtils.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Library\support\URLUtils.c</name>
    </file>
  </group>
</project>


