# IAR project platforms.ewp, settings and files
configuration FRDM_K64 (ARM, debug)
  General.OGChipSelectEditMenu: MK64FN1M0xxx12 Freescale MK64FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: DEBUG; CPU_MK64FN1M0VMD12; IAR; FSL_RTOS_FREE_RTOS
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\Platform; ..\Library\support; ..\Demos\COM.Apple.HomeKit; ..\MICO; ..\Platform\FRDM_K64; ..\Platform\Common\Cortex-M4; ..\Platform\Common\Cortex-M4\Freescale; ..\include; ..\External; ..\Platform\include; ..\Platform\Common\Drivers\spi_flash
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: platforms.srec
  ILINK.IlinkOutputFile: platforms.out
  ILINK.IlinkIcfFile: ..\Platform\FRDM_K64\K64FN1Mxxx12_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FRDM_K64_SPP (ARM)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ..\Platform; ..\Library\support; ..\Demos\COM.MXCHIP.SPP; ..\MICO; ..\Platform\FRDM_K64; ..\Platform\Common\Cortex-M4; ..\Platform\Common\Cortex-M4\Freescale; ..\include; ..\External; ..\Platform\include; ..\Platform\Common\Drivers\spi_flash
  group Applications/Bootloader
    ../Bootloader/: BootloaderEntrance.c Getline.c menu.c Update_for_OTA.c ymodem.c
  group Applications/COM.MXCHIP.HA
    ../Demos/COM.MXCHIP.HA/: HaProtocol.c LocalTcpServer.c MICOAppEntrance.c MICOBonjour.c MICOConfigDelegate.c RemoteTcpClient.c stm32f2xx_it.c UartRecv.c
  group Applications/COM.MXCHIP.HOMEKIT
    ../Demos/COM.Apple.HomeKit/: HomeKitPairlist.c HomekitProfiles.c HomeKitSecurity_Debug.a HomeKitSecurity_Release.a HomeKitServer.c HomeKitUserInterface.c MICOAppEntrance.c MICOBonjour.c MICOConfigDelegate.c
  group Applications/COM.MXCHIP.SPP
    ../Demos/COM.MXCHIP.SPP/: LocalTcpServer.c MICOAppEntrance.c MICOBonjour.c MICOConfigDelegate.c RemoteTcpClient.c SppProtocol.c UartRecv.c
  group Applications/WeiChat.SPP
    ../Demos/COM.WECHAT.SPP/: LocalTcpServer.c MICOAppEntrance.c MICOBonjour.c MICOConfigDelegate.c RemoteTcpClient.c SppProtocol.c UartRecv.c
  group External/Curve25519
    ../External/Curve25519/: curve25519-donna.c
  group External/JSON-C
    ../External/JSON-C/: arraylist.c debug.c json_object.c json_tokener.c json_util.c linkhash.c printbuf.c
  group External/SHAUtils
    ../External/SHAUtils/: hkdf.c hmac.c sha1.c sha224-256.c sha384-512.c usha.c
  group include
    ../include/: MICO.h MicoAES.h MicoAlgorithm.h MicoPlatform.h MICORTOS.h MicoSocket.h MicoSRPServer.h MicoWlan.h
  group include/MicoDrivers
    ../include/MicoDrivers/: MicoDriverAdc.h MicoDriverFlash.h MicoDriverGpio.h MicoDriverI2c.h MicoDriverMFiAuth.h MicoDriverPwm.h MicoDriverRng.h MicoDriverRtc.h MicoDriverSpi.h MicoDriverUart.h MicoDriverWdg.h
  group Library
    ../Library/: MICOConfig.c MicoCrypto.a MicoSrpServer.a mxchipWNet_cm3_sdio.a mxchipWNet_cm3_spi.a mxchipWNet_cm4f_sdio.a mxchipWNet_cm4f_spi.a
  group MICO
    ../MICO/: MICOConfigMenu.c MICOConfigServer.c MICOEntrance.c MICONotificationCenter.c MICONTPClient.c MICOParaStorage.c MICOSystemMonitor.c
  group MICO/Easylink
    ../MICO/EasyLink/: EasyLink.c
  group MICO/WAC
    ../MICO/WAC/: MFi_WAC_CM3_Debug.a MFi_WAC_CM3_Release.a
  group MICO/WPS
    ../MICO/WPS/: WPS.c
  group Platforms/boards/FRDM_K64
    ../Platform/FRDM_K64/utilities/: fsl_debug_console.c mem_tools.c
    ../Platform/FRDM_K64/irq_handler/: fsl_dspi_irq.c fsl_edma_irq.c
    ../Platform/FRDM_K64/hal/: fsl_edma_common.c fsl_edma_driver.c fsl_uart_common.c fsl_uart_driver.c fsl_uart_edma_driver.c fsl_uart_hal.c fsl_uart_irq.c
    ../Platform/FRDM_K64/boards/: gpio_pins.c hardware_init.c pin_mux.c
    ../Platform/FRDM_K64/: platform.c
    ../Platform/FRDM_K64/startup/: startup.c startup_MK64F12.s system_MK64F12.c
  group Platforms/common/Cortex-m4
    ../Platform/Common/Cortex-M4/: crt0_IAR.c hardfault.c
  group Platforms/common/Driver
    ../Platform/Common/Drivers/: MicoDriverMFiAuth.a
  group Platforms/common/Driver/spi_flash
    ../Platform/Common/Drivers/spi_flash/: spi_flash.c
  group Platforms/common/IAR
    ../Platform/Common/IAR/: stdio_IAR.c
  group Platforms/vendor/FSL_MK64Fxx12
    ../Platform/FRDM_K64/hal/: edma.c
    ../Platform/Common/Cortex-M4/Freescale/: flash_kinetis.c flash_kinetisRamFunc.c fsl_rtc_irq.c gpio_irq.c k64_gpio.c k64_spi.c ksdk_freertos_lib.a ksdk_platform.c MicoDriverAdc.c MicoDriverFlash.c MicoDriverGpio.c MicoDriverI2c.c MicoDriverPwm.c MicoDriverRng.c MicoDriverRtc.c MicoDriverSpi.c MicoDriverUart.c MicoDriverWdg.c wwd_bus.c
    ../Platform/Common/Cortex-M4/Freescale/EMW1062_Driver/: read_wifi_firmware.c wlan_platform.c
    ../Platform/Common/Cortex-M4/Freescale/EMW1062_Driver/SPI/: wwd_bus.c
  group support
    ../Library/support/: AESUtils.c HTTPUtils.c MDNSUtils.c RingBufferUtils.c SecurityUtils.c SHAUtils.c SocketUtils.c StringUtils.c TimeUtils.c TLVUtils.c URLUtils.c
