<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>NXP54xx_SPP</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>Applications</name>
    <group>
      <name>bootloader</name>
    </group>
    <group>
      <name>COM.MXCHIP.HOMEKIT</name>
    </group>
    <group>
      <name>COM.MXCHIP.SPP</name>
      <file>
        <name>$PROJ_DIR$\..\..\Demos\COM.MXCHIP.SPP\LocalTcpServer.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Demos\COM.MXCHIP.SPP\MICOAppEntrance.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Demos\COM.MXCHIP.SPP\MICOBonjour.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Demos\COM.MXCHIP.SPP\MICOConfigDelegate.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Demos\COM.MXCHIP.SPP\RemoteTcpClient.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Demos\COM.MXCHIP.SPP\SppProtocol.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Demos\COM.MXCHIP.SPP\UartRecv.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>External</name>
    <group>
      <name>Curve25519</name>
      <file>
        <name>$PROJ_DIR$\..\..\External\Curve25519\curve25519-donna.c</name>
      </file>
    </group>
    <group>
      <name>GladmanAES</name>
    </group>
    <group>
      <name>json-c</name>
      <file>
        <name>$PROJ_DIR$\..\..\External\JSON-C\arraylist.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\External\JSON-C\debug.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\External\JSON-C\json_object.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\External\JSON-C\json_tokener.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\External\JSON-C\json_util.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\External\JSON-C\linkhash.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\External\JSON-C\printbuf.c</name>
      </file>
    </group>
    <group>
      <name>SHAUtils</name>
    </group>
  </group>
  <group>
    <name>include</name>
    <group>
      <name>MicoDriver</name>
      <file>
        <name>$PROJ_DIR$\..\..\include\MicoDrivers\MicoDriverAdc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\include\MicoDrivers\MicoDriverFlash.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\include\MicoDrivers\MicoDriverGpio.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\include\MicoDrivers\MicoDriverI2c.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\include\MicoDrivers\MicoDriverMFiAuth.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\include\MicoDrivers\MicoDriverPwm.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\include\MicoDrivers\MicoDriverRng.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\include\MicoDrivers\MicoDriverRtc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\include\MicoDrivers\MicoDriverSpi.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\include\MicoDrivers\MicoDriverUart.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\include\MicoDrivers\MicoDriverWdg.h</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\..\..\include\MICO.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\include\MicoAES.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\include\MicoAlgorithm.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\include\MicoPlatform.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\include\MICORTOS.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\include\MicoSocket.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\include\MicoSRPServer.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\include\MicoWlan.h</name>
    </file>
  </group>
  <group>
    <name>Library</name>
    <file>
      <name>$PROJ_DIR$\..\..\Library\MICOConfig.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Library\mxchipWNet_cm3_sdio.a</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Library\mxchipWNet_cm3_spi.a</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Library\mxchipWNet_cm4f_sdio.a</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Library\mxchipWNet_cm4f_spi.a</name>
    </file>
  </group>
  <group>
    <name>MICO</name>
    <group>
      <name>EasyLink</name>
      <file>
        <name>$PROJ_DIR$\..\..\MICO\EasyLink\EasyLink.c</name>
      </file>
    </group>
    <group>
      <name>WAC</name>
      <file>
        <name>$PROJ_DIR$\..\..\MICO\WAC\MFi_WAC_CM3_Debug.a</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\MICO\WAC\MFi_WAC_CM3_Release.a</name>
      </file>
    </group>
    <group>
      <name>WPS</name>
      <file>
        <name>$PROJ_DIR$\..\..\MICO\WPS\WPS.c</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\..\..\MICO\MICOConfigMenu.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\MICO\MICOConfigServer.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\MICO\MICOEntrance.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\MICO\MICONotificationCenter.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\MICO\MICONTPClient.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\MICO\MICOParaStorage.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\MICO\MICOSystemMonitor.c</name>
    </file>
  </group>
  <group>
    <name>Platform</name>
    <group>
      <name>BoardConfig</name>
      <group>
        <name>NXP_LPC54102</name>
        <file>
          <name>$PROJ_DIR$\..\..\Platform\BoardConfig\LPCXpresso54102\iar_startup_lpc540xx.s</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\Platform\BoardConfig\LPCXpresso54102\pinmapping.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\Platform\BoardConfig\LPCXpresso54102\platform.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\Platform\BoardConfig\LPCXpresso54102\spi_flash_api.c</name>
        </file>
      </group>
    </group>
    <group>
      <name>common</name>
      <group>
        <name>Cortex-m4</name>
        <group>
          <name>CMSIS</name>
        </group>
      </group>
      <group>
        <name>Drivers</name>
        <group>
          <name>spi_flash</name>
          <file>
            <name>$PROJ_DIR$\..\..\Platform\Common\Drivers\spi_flash\spi_flash.c</name>
          </file>
        </group>
      </group>
    </group>
    <group>
      <name>Vendors</name>
      <group>
        <name>NXP_LPC54xx</name>
        <group>
          <name>EWM1062</name>
          <file>
            <name>$PROJ_DIR$\..\..\Platform\vendor\nxp\LPC54xx\EMW1062_Driver\read_wifi_firmware.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\Platform\vendor\nxp\LPC54xx\EMW1062_Driver\wlan_platform.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\Platform\vendor\nxp\LPC54xx\EMW1062_Driver\SPI\wwd_bus.c</name>
          </file>
        </group>
        <group>
          <name>nxp_drivers</name>
          <file>
            <name>$PROJ_DIR$\..\..\Platform\vendor\nxp\LPC54xx\NXP_drivers\board_nxp_lpcxpresso_54000.a</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\Platform\vendor\nxp\LPC54xx\NXP_drivers\chip_540xx_lib.a</name>
          </file>
        </group>
        <file>
          <name>$PROJ_DIR$\..\..\Platform\vendor\nxp\LPC54xx\gpio_irq.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\Platform\vendor\nxp\LPC54xx\hardfault.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\Platform\vendor\nxp\LPC54xx\lpc1800_freertos.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\Platform\vendor\nxp\LPC54xx\lpc_mico.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\Platform\vendor\nxp\LPC54xx\MicoDriverAdc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\Platform\vendor\nxp\LPC54xx\MicoDriverFlash.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\Platform\vendor\nxp\LPC54xx\MicoDriverGpio.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\Platform\vendor\nxp\LPC54xx\MicoDriverI2c.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\Platform\vendor\nxp\LPC54xx\MicoDriverPwm.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\Platform\vendor\nxp\LPC54xx\MicoDriverRng.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\Platform\vendor\nxp\LPC54xx\MicoDriverRtc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\Platform\vendor\nxp\LPC54xx\MicoDriverSpi.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\Platform\vendor\nxp\LPC54xx\MicoDriverUart.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\Platform\vendor\nxp\LPC54xx\MicoDriverWdg.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\Platform\vendor\nxp\LPC54xx\nxp_platform.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\Platform\vendor\nxp\LPC54xx\platform_api.c</name>
        </file>
      </group>
    </group>
  </group>
  <group>
    <name>Support</name>
    <file>
      <name>$PROJ_DIR$\..\..\Library\support\AESUtils.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Library\support\HTTPUtils.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Library\support\MDNSUtils.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Library\support\RingBufferUtils.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Library\support\SecurityUtils.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Library\support\SHAUtils.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Library\support\SocketUtils.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Library\support\StringUtils.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Library\support\TimeUtils.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Library\support\TLVUtils.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Library\support\URLUtils.c</name>
    </file>
  </group>
</project>


