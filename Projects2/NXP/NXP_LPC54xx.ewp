# IAR project NXP_LPC54xx.ewp, settings and files
configuration NXP54xx_SPP (ARM, debug)
  General.OGChipSelectEditMenu: LPC4088 NXP LPC4088
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: CORE_M4; DEBUG
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\Platform; ..\..\Library\support; ..\..\Demos\COM.MXCHIP.SPP; ..\..\MICO; ..\..\Platform\BoardConfig\LPCXpresso54102; ..\..\Platform\vendor\nxp\LPC54xx\NXP_drivers\chip_540xx\config; ..\..\Platform\vendor\nxp\LPC54xx\NXP_drivers\chip_common; ..\..\Platform\vendor\nxp\LPC54xx\NXP_drivers\chip_540xx; ..\..\Platform\NXP\lpc_board\board_common; ..\..\Platform\NXP\lpc_board\boards_540xx\nxp_lpcxpresso_54000; ..\..\include; ..\..\External; ..\..\Platform\include; ..\..\Platform\Common\Cortex-M4; ..\..\Platform\Common\Drivers\spi_flash
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: NXP_LPC54xx.out
  ILINK.IlinkIcfFile: \\psf\Home\Documents\work\MICO\MICO\Platform\BoardConfig\LPCXpresso54102\LPC540xx_heap.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Applications/COM.MXCHIP.SPP
    ../../Demos/COM.MXCHIP.SPP/: LocalTcpServer.c MICOAppEntrance.c MICOBonjour.c MICOConfigDelegate.c RemoteTcpClient.c SppProtocol.c UartRecv.c
  group External/Curve25519
    ../../External/Curve25519/: curve25519-donna.c
  group External/json-c
    ../../External/JSON-C/: arraylist.c debug.c json_object.c json_tokener.c json_util.c linkhash.c printbuf.c
  group include
    ../../include/: MICO.h MicoAES.h MicoAlgorithm.h MicoPlatform.h MICORTOS.h MicoSocket.h MicoSRPServer.h MicoWlan.h
  group include/MicoDriver
    ../../include/MicoDrivers/: MicoDriverAdc.h MicoDriverFlash.h MicoDriverGpio.h MicoDriverI2c.h MicoDriverMFiAuth.h MicoDriverPwm.h MicoDriverRng.h MicoDriverRtc.h MicoDriverSpi.h MicoDriverUart.h MicoDriverWdg.h
  group Library
    ../../Library/: MICOConfig.c mxchipWNet_cm3_sdio.a mxchipWNet_cm3_spi.a mxchipWNet_cm4f_sdio.a mxchipWNet_cm4f_spi.a
  group Library/Support
    ../../Library/support/: AESUtils.c HTTPUtils.c MDNSUtils.c RingBufferUtils.c SecurityUtils.c SHAUtils.c SocketUtils.c StringUtils.c TimeUtils.c TLVUtils.c URLUtils.c
  group Library1127
    ../../Library1127/: MICOConfig.c mxchipWNet_cm4f_spi.a
  group Library1127/support
    ../../Library1127/support/: AESUtils.c HTTPUtils.c MDNSUtils.c RingBufferUtils.c SecurityUtils.c SHAUtils.c SocketUtils.c StringUtils.c TimeUtils.c TLVUtils.c URLUtils.c
  group MICO
    ../../MICO/: MICOConfigMenu.c MICOConfigServer.c MICOEntrance.c MICONotificationCenter.c MICONTPClient.c MICOParaStorage.c MICOSystemMonitor.c
  group MICO/EasyLink
    ../../MICO/EasyLink/: EasyLink.c
  group MICO/WAC
    ../../MICO/WAC/: MFi_WAC_CM3_Debug.a MFi_WAC_CM3_Release.a
  group MICO/WPS
    ../../MICO/WPS/: WPS.c
  group Platform/BoardConfig/NXP_LPC54102
    ../../Platform/BoardConfig/LPCXpresso54102/: iar_startup_lpc540xx.s pinmapping.c platform.c spi_flash_api.c
  group Platform/common/Drivers/spi_flash
    ../../Platform/Common/Drivers/spi_flash/: spi_flash.c
  group Platform/Vendors/NXP_LPC54xx
    ../../Platform/vendor/nxp/LPC54xx/: gpio_irq.c hardfault.c lpc1800_freertos.c lpc_mico.c MicoDriverAdc.c MicoDriverFlash.c MicoDriverGpio.c MicoDriverI2c.c MicoDriverPwm.c MicoDriverRng.c MicoDriverRtc.c MicoDriverSpi.c MicoDriverUart.c MicoDriverWdg.c nxp_platform.c platform_api.c
  group Platform/Vendors/NXP_LPC54xx/EWM1062
    ../../Platform/vendor/nxp/LPC54xx/EMW1062_Driver/: read_wifi_firmware.c wlan_platform.c
    ../../Platform/vendor/nxp/LPC54xx/EMW1062_Driver/SPI/: wwd_bus.c
  group Platform/Vendors/NXP_LPC54xx/nxp_drivers
    ../../Platform/vendor/nxp/LPC54xx/NXP_drivers/: board_nxp_lpcxpresso_54000.a chip_540xx_lib.a
