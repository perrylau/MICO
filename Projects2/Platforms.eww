<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\NXP\NXP_LPC54xx.ewp</path>
  </project>
  <batchBuild/>
</workspace>


