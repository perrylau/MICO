# Keil uVision project SPP.uvproj, settings and files
target SPP (ARM-ADS)
  device: STM32F205ZG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: SPP
  c flags: Optim=4 uC99=1
  c define: USE_STDPERIPH_DRIVER DEBUG
  c include: ..\..\..\Demos\COM.MXCHIP.SPP;..\..\..\Platform\EMW3162;..\..\..\Library\support;..\..\..\include;..\..\..\Platform\include;..\..\..\Platform\Common\Cortex-M3;..\..\..\Platform\Common\Cortex-M3\STM32F2xx;..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv;..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv\STM32F2xx_StdPeriph_Driver\inc;..\..\..\External;..\..\..\MICO
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group SPP
    ./: startup_stm32f2xx.s
    ../../../Demos/COM.MXCHIP.SPP/: LocalTcpServer.c MICOAppEntrance.c MICOBonjour.c MICOConfigDelegate.c RemoteTcpClient.c SppProtocol.c UartRecv.c
  group Library
    ../../../Library/: MICOConfig.c mxchipWNet_cm3_sdio.a
  group Mico
    ../../../MICO/: MICOConfigMenu.c MICOConfigServer.c MICOEntrance.c MICONotificationCenter.c MICONTPClient.c MICOParaStorage.c MICOSystemMonitor.c
    ../../../MICO/EasyLink/: EasyLink.c
    ../../../MICO/SoftAP/: EasyLinkSoftAP.c
    ../../../MICO/WPS/: WPS.c
  group platform
    ../../../Platform/Common/Cortex-M3/STM32F2xx/EMW1062_Driver/SDIO/: wlan_bus.c
    ../../../Platform/Common/Cortex-M3/STM32F2xx/EMW1062_Driver/: wlan_platform.c read_wifi_firmware.c
    ../../../Platform/Common/Cortex-M3/STM32F2xx/STM32F2xx_Drv/: system_stm32f2xx.c
    ../../../Platform/Common/Cortex-M3/STM32F2xx/STM32F2xx_Drv/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_cryp.c stm32f2xx_cryp_aes.c stm32f2xx_cryp_des.c stm32f2xx_cryp_tdes.c stm32f2xx_dac.c stm32f2xx_dbgmcu.c stm32f2xx_dcmi.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_hash.c stm32f2xx_hash_md5.c stm32f2xx_hash_sha1.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c
  group boardconfig
    ../../../Platform/EMW3162/: platform.c
  group common
    ../../../Platform/Common/Cortex-M3/: crt0_IAR.c hardfault.c
    ../../../Platform/Common/Cortex-M3/STM32F2xx/: gpio_irq.c MicoDriverAdc.c MicoDriverFlash.c MicoDriverGpio.c MicoDriverI2c.c MicoDriverPwm.c MicoDriverRng.c MicoDriverRtc.c MicoDriverSpi.c MicoDriverUart.c MicoDriverWdg.c rtc.c stm32f2xx_platform.c usbh_conf.c
  group support
    ../../../Library/support/: AESUtils.c HTTPUtils.c MDNSUtils.c RingBufferUtils.c SecurityUtils.c SHAUtils.c SocketUtils.c StringUtils.c TimeUtils.c TLVUtils.c URLUtils.c
  group External
    ../../../External/Curve25519/: curve25519-donna.c
    ../../../External/JSON-C/: arraylist.c debug.c json_object.c json_tokener.c json_util.c linkhash.c printbuf.c
    ../../../External/SHAUtils/: hkdf.c hmac.c sha1.c sha224-256.c sha384-512.c usha.c
