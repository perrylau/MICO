# Keil uVision project 3162_uv.uvproj, settings and files
target Bootloader (ARM-ADS)
  device: STM32F205ZG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: 3162_uv
  AfterMake: fromelf.exe --bin -o "#L.bin" "#L"
  c flags: Optim=4 uC99=1
  c define: USE_STDPERIPH_DRIVER DEBUG BOOTLOADER
  c include: ..\Bootloader;..\Platform\EMW3162;..\Library\support;..\include;..\Platform\include;..\Platform\Common\Cortex-M3;..\Platform\Common\Cortex-M3\STM32F2xx;..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv;..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv\STM32F2xx_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group test
    ./: startup_stm32f2xx.s
    ../Bootloader/: BootloaderEntrance.c Getline.c menu.c Update_for_OTA.c ymodem.c
    ./test/: Retarget.c
  group stm32f2xx_std_drivers
    ../Platform/Common/Cortex-M3/STM32F2xx/STM32F2xx_Drv/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_cryp.c stm32f2xx_cryp_aes.c stm32f2xx_cryp_des.c stm32f2xx_cryp_tdes.c stm32f2xx_dac.c stm32f2xx_dbgmcu.c stm32f2xx_dcmi.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_hash.c stm32f2xx_hash_md5.c stm32f2xx_hash_sha1.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c
  group stm32f2xx
    ../Platform/Common/Cortex-M3/STM32F2xx/STM32F2xx_Drv/: system_stm32f2xx.c
    ../Platform/Common/Cortex-M3/STM32F2xx/: stm32f2xx_platform.c MicoDriverUart.c MicoDriverFlash.c gpio_irq.c MicoDriverAdc.c MicoDriverGpio.c MicoDriverI2c.c MicoDriverPwm.c MicoDriverRng.c MicoDriverRtc.c MicoDriverSpi.c rtc.c
  group support
    ../Library/support/: RingBufferUtils.c StringUtils.c
  group Board_3162
    ../Platform/EMW3162/: platform.c
    ../Platform/Common/Cortex-M3/: crt0_IAR.c hardfault.c
